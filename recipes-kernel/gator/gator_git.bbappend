LIC_FILES_CHKSUM = "file://driver/COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

#SRCREV = "f0ddf6b40e42579f2275974620399fb3406d0c18"
#PV = "5.21.1+git${SRCPV}"

SRCREV = "7ca6004c0b05138c49b9b21e0045487f55a60ab6"
PV = "5.22+git${SRCPV}"
