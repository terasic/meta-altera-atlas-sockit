# Override build config

EXTRA_OECONF = "--program-prefix= --program-suffix= --with-x --without-perl --disable-openmp --without-xml --disable-opencl"
